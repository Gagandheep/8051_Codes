ORG 00H
	
	MOV R0, #30H
	MOV R1, #40H
	MOV R2, #0AH
	LOOP0:
	MOV A, @R0
	MOV @R1, A
	INC R0
	INC R1
	DJNZ R2, LOOP0
	
	MOV R2, #09H
	MOV 50H, #09H
	
	LOOP1:
	MOV R0, #40H
	MOV R1, #41H
	MOV R3, 50H
	
	LOOP2:
	MOV A, @R0
	SUBB A, @R1
	JNC NEXT
	MOV 04H, @R0
	MOV A, @R1
	MOV @R0, A
	MOV @R1, 04H
	CLR C
	
	NEXT:
	INC R0
	INC R1
	DJNZ R3, LOOP2
	
	DEC 50H
	DJNZ R2, LOOP1
	
	HERE:
	SJMP HERE
	
END