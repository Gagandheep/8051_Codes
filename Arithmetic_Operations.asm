			ORG 00H
	
MOV R0,#0F4H
MOV R1,#041H

// ADD
MOV A,R0
ADD A,R1
MOV 31H,A
MOV A,#00H
ADDC A,#00H
MOV 30H,A

// SUBTRACT
MOV A,R0
SUBB A,R1
MOV 33H,A
MOV A,#00H
ADDC A,#00H
MOV 32H,A

// MULTIPLY
MOV A,R0
MOV B,R1
MUL AB
MOV 34H,B
MOV 35H,A

// DIVIDE
MOV A,R0
MOV B,R1
DIV AB
MOV 36H,B
MOV 37H,A

HERE:
SJMP HERE

END
