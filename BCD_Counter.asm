ORG 00H

MOV R2,30H
MOV R1,#5H
MOV A,#99H

CJNE R2,#0FFH,DOWN

MOV R0,#00H
MOV A,#00H
UP:
MOV R0,A
INC A
CLR C
DA A
SJMP UP

DOWN:
MOV R1,#00H

LOOP:
MOV R0,01H
DEC R1
CJNE R1,#0FFH,NOT_0
MOV R1,#99H
SJMP LOOP

NOT_0:
MOV A,R1
MOV B,#10H
DIV AB
MOV R3,B
CJNE R3,#0FH,NO_SUB
MOV A,R1
SUBB A,#06H
MOV R1,A
NO_SUB:
SJMP LOOP

END