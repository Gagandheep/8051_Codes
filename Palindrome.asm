ORG 0100H
	
	DB "PALINDROME_EMORDNILAP"

ORG 00H
	
	MOV DPTR, #0100H
	LOOP:
	MOV A, R2
	MOVC A, @A+DPTR
	INC R2
	JNZ LOOP
	DEC R2
	
	MOV A, R2
	MOV B, #02H
	DIV AB
	MOV R3, A
	MOV A, B
	DEC R2
	JZ CHECK
	INC R3
	
	CLR F0
	CHECK:
	MOV A, R1
	MOVC A, @A+DPTR
	MOV R4, A
	MOV A, R2
	MOVC A, @A+DPTR
	CJNE A, 04H, DONE
	INC R1
	DEC R2
	DJNZ R3, CHECK
	SETB 00H
	
	DONE:
	SETB 01H
	
	HERE:
	SJMP HERE

END
	