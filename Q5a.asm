ORG 00H
	
	MOV R0, #60H
	MOV R2, #0AH
	MOV R3, #80H
	
	LOOP:
	MOV A, @R0
	RLC A
	
	JC NOT_POS
	INC R1
	SETB F0
	
	NOT_POS:
	MOV A, @R0
	XRL A, R3
	RLC A
	
	JNC SAME_SIGN
	JB F0, UPDATE
	SJMP CONTINUE
	
	SAME_SIGN:
	MOV A, @R0
	SUBB A, R3
	
	JC CONTINUE
	UPDATE:
	MOV 03H, @R0
	MOV 04H, R0
	
	CONTINUE:
	INC R0
	CLR F0
	DJNZ R2, LOOP

	SJMP $

END